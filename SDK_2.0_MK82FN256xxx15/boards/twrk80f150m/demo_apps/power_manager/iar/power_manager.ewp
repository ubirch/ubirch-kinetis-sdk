# IAR project power_manager.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 Freescale MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK80FN256VDC15; TWR_K80F150M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK80F25615/drivers; ..; ../../../../../devices/MK80F25615/utilities; ../../..; ../../../../../devices/MK80F25615
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: power_manager.out
  ILINK.IlinkIcfFile: MK80FN256xxx15_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK80FN256VDC15; TWR_K80F150M; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MK80F25615/iar/: startup_MK80F25615.s
    ../../../../../devices/MK80F25615/: system_MK80F25615.c system_MK80F25615.h
  group doc
    ../: readme.txt
  group source
    ../: clock_mcg.c power_manager.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group drivers
    ../../../../../devices/MK80F25615/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_llwu.h fsl_llwu.c fsl_pmc.h fsl_pmc.c fsl_smc.h fsl_smc.c fsl_rcm.c fsl_rcm.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../devices/MK80F25615/utilities/: fsl_debug_console.c fsl_debug_console.h
  group notifier
    ../../../../../devices/MK80F25615/utilities/: fsl_notifier.c fsl_notifier.h
