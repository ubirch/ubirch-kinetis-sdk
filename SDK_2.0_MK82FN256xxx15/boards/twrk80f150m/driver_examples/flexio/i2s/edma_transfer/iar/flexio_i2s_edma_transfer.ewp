# IAR project flexio_i2s_edma_transfer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 Freescale MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK80FN256VDC15; TWR_K80F150M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/MK80F25615/drivers; ../..; ..; ../../../../../../../devices/MK80F25615/utilities; ../../../../..; ../../../../../../../devices/MK80F25615
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: flexio_i2s_edma_transfer.out
  ILINK.IlinkIcfFile: MK80FN256xxx15_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK80FN256VDC15; TWR_K80F150M; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../../devices/MK80F25615/iar/: startup_MK80F25615.s
    ../../../../../../../devices/MK80F25615/: system_MK80F25615.c system_MK80F25615.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/MK80F25615/drivers/: fsl_i2c.h fsl_i2c.c fsl_lpuart.h fsl_lpuart.c fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_flexio.c fsl_flexio.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_edma.c fsl_flexio_i2s_edma.h fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c
  group codec
    ../: fsl_sgtl5000.h fsl_sgtl5000.c
  group source
    ../: flexio_i2s_edma_transfer.c
    ../../: music.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../../devices/MK80F25615/utilities/: fsl_debug_console.c fsl_debug_console.h
