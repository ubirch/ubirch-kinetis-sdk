# Keil uVision project flexio_spi_int_dspi_transfer_master.uvprojx, settings and files
target flexio_spi_int_dspi_transfer_master Debug (ARM-ADS)
  device: MK80FN256xxx15 Freescale
  pack: Keil.Kinetis_K80_DFP.1.0.0.pack
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: flexio_spi_int_dspi_transfer_master.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK80FN256VDC15, TWR_K80F150M, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../../../../CMSIS/Include;../../../../../../../../devices;../../../../../../../../devices/MK80F25615/drivers;../..;..;../../../../../../../../devices/MK80F25615/utilities;../../../../../..;../../../../../../../../devices/MK80F25615
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK80FN256xxx15_flash.scf
  link misc: --remove
  group startup
    ../../../../../../../../devices/MK80F25615/arm/: startup_MK80F25615.s
    ../../../../../../../../devices/MK80F25615/: system_MK80F25615.c system_MK80F25615.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../../devices/MK80F25615/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_flexio.c fsl_flexio.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_dspi.h fsl_dspi.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
  group source
    ../: flexio_spi_int_dspi_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../../../devices/MK80F25615/utilities/: fsl_debug_console.c fsl_debug_console.h
target flexio_spi_int_dspi_transfer_master Release (ARM-ADS)
  device: MK80FN256xxx15 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: flexio_spi_int_dspi_transfer_master.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK80FN256VDC15, TWR_K80F150M, TOWER
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK80FN256xxx15_flash.scf
  link misc: --remove
