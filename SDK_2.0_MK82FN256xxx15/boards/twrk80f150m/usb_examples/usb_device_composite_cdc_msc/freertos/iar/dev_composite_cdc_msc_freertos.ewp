# IAR project dev_composite_cdc_msc_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 Freescale MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MK80FN256VDC15; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_FREERTOS; FSL_RTOS_FREE_RTOS; TWR_K80F150M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F; ../../../../../../rtos/freertos_8.2.3/Source/include; ..; ../../../../../../rtos/freertos_8.2.3/Source; ../../../../../../devices/MK80F25615/utilities; ../../../../../../middleware/usb_1.0.0; ../../../../../../middleware/usb_1.0.0/osa; ../../../../../../middleware/usb_1.0.0/include; ../../../../../../middleware/usb_1.0.0/device; ../../../../../../CMSIS/Include; ../../../..; ../../../../../../devices/MK80F25615/drivers; ../../../../../../devices/MK80F25615
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: dev_composite_cdc_msc_freertos.out
  ILINK.IlinkIcfFile: MK80FN256xxx15_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK80FN256VDC15; USB_STACK_FREERTOS_HEAP_SIZE=32768; USB_STACK_FREERTOS; FSL_RTOS_FREE_RTOS; TWR_K80F150M; TOWER
  ICCARM.CCOptLevel: 3
  group freertos
    ../../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../rtos/freertos_8.2.3/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group startup
    ../../../../../../devices/MK80F25615/iar/: startup_MK80F25615.s
    ../../../../../../devices/MK80F25615/: system_MK80F25615.c system_MK80F25615.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.0.0/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/khci
    ../../../../../../middleware/usb_1.0.0/device/: usb_device_khci.c usb_device_khci.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/cdc
    ../: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb/device/class/msc
    ../: usb_device_msc.c usb_device_msc.h usb_device_msc_ufi.c usb_device_msc_ufi.h
  group usb/device/include
    ../../../../../../middleware/usb_1.0.0/device/: usb_device.h
  group usb/include
    ../../../../../../middleware/usb_1.0.0/include/: usb.h
  group drivers
    ../../../../../../devices/MK80F25615/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_mpu.h fsl_mpu.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
  group osa
    ../../../../../../middleware/usb_1.0.0/osa/: usb_osa.h usb_osa_freertos.h usb_osa_freertos.c
  group sources
    ../: composite.c composite.h disk.c disk.h usb_device_descriptor.c usb_device_descriptor.h virtual_com.c virtual_com.h usb_device_config.h FreeRTOSConfig.h
  group utilities
    ../../../../../../devices/MK80F25615/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
