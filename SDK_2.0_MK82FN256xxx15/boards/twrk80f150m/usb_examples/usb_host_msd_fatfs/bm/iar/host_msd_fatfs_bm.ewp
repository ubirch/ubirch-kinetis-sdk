# IAR project host_msd_fatfs_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 Freescale MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; CPU_MK80FN256VDC15; USB_STACK_BM; TWR_K80F150M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/fatfs_0.11a/src; ../../../../../../middleware/fatfs_0.11a/src/fsl_usb_disk; ../../../../../../devices/MK80F25615/utilities; ../../../../../../middleware/usb_1.0.0; ../../../../../../middleware/usb_1.0.0/osa; ../../../../../../middleware/usb_1.0.0/include; ../../../../../../CMSIS/Include; ../../../..; ../../../../../../middleware/usb_1.0.0/host; ../../../../../../devices/MK80F25615/drivers; ../../../../../../middleware/usb_1.0.0/host/class; ../../../../../../devices/MK80F25615
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: host_msd_fatfs_bm.out
  ILINK.IlinkIcfFile: MK80FN256xxx15_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK80FN256VDC15; USB_STACK_BM; TWR_K80F150M; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/MK80F25615/iar/: startup_MK80F25615.s
    ../../../../../../devices/MK80F25615/: system_MK80F25615.c system_MK80F25615.h
  group usb/host
    ../../../../../../middleware/usb_1.0.0/host/: usb_host_khci.c usb_host_khci.h usb_host.h usb_host_hci.c usb_host_hci.h usb_host_devices.c usb_host_devices.h usb_host_framework.h usb_host_framework.c
  group usb/host/class
    ../../../../../../middleware/usb_1.0.0/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb/include
    ../../../../../../middleware/usb_1.0.0/include/: usb.h
  group drivers
    ../../../../../../devices/MK80F25615/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_gpio.h fsl_gpio.c fsl_mpu.h fsl_mpu.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c
  group osa
    ../../../../../../middleware/usb_1.0.0/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group sources
    ../: app.c host_msd_fatfs.c host_msd_fatfs.h usb_host_config.h
    ../../../../../../middleware/fatfs_0.11a/src/fsl_usb_disk/: fsl_usb_disk_bm.c fsl_usb_disk.h
  group sources/fatfs
    ../../../../../../middleware/fatfs_0.11a/src/: diskio.c diskio.h ff.c ff.h
    ../../../../../../middleware/fatfs_0.11a/src/option/: unicode.c
  group utilities
    ../../../../../../devices/MK80F25615/utilities/: fsl_debug_console.c fsl_debug_console.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
