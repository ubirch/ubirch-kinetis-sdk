# Keil uVision project dev_video_flexio_ov7670_freertos.uvprojx, settings and files
target dev_video_flexio_ov7670_freertos Debug (ARM-ADS)
  device: MK82FN256xxx15 Freescale
  pack: Keil.Kinetis_K80_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_video_flexio_ov7670_freertos.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: _DEBUG=1, CPU_MK82FN256VDC15, USB_STACK_FREERTOS_HEAP_SIZE=32768, USB_STACK_FREERTOS, FSL_RTOS_FREE_RTOS, FRDM_K82F, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ../../../../../../rtos/freertos_8.2.3/Source/portable/RVDS/ARM_CM4F;../../../../../../rtos/freertos_8.2.3/Source/include;..;../ov7670;../../../../../../rtos/freertos_8.2.3/Source;../../../../../../devices/MK82F25615/utilities;../../../../../../middleware/usb_1.0.0;../../../../../../middleware/usb_1.0.0/osa;../../../../../../middleware/usb_1.0.0/include;../../../../../../middleware/usb_1.0.0/device;../../../../../../CMSIS/Include;../../../..;../../../../../../devices/MK82F25615/drivers;../../../../../../devices/MK82F25615
  asm misc: --cpreproc_opts '-DDEBUG'
  asm include: ..;../ov7670
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK82FN256xxx15_flash.scf
  link misc: --remove
  group freertos:portable
    ../../../../../../rtos/freertos_8.2.3/Source/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group startup
    ../../../../../../devices/MK82F25615/arm/: startup_MK82F25615.s
    ../../../../../../devices/MK82F25615/: system_MK82F25615.c system_MK82F25615.h
  group usb-device-source-khci
    ../../../../../../middleware/usb_1.0.0/device/: usb_device_khci.c usb_device_khci.h
  group drivers
    ../../../../../../devices/MK82F25615/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_i2c.h fsl_i2c.c fsl_port.h fsl_flexio.c fsl_flexio.h fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c fsl_flexio_camera.c fsl_flexio_camera.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_mpu.h fsl_mpu.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c
  group osa
    ../../../../../../middleware/usb_1.0.0/osa/: usb_osa.h usb_osa_freertos.h usb_osa_freertos.c
  group usb-device-source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.0.0/device/: usb_device_dci.c usb_device_dci.h
  group usb-device-class
    ../: usb_device_class.c usb_device_class.h
  group usb-device-class-video
    ../: usb_device_video.c usb_device_video.h
  group sources
    ../: usb_device_descriptor.c usb_device_descriptor.h video_camera.c video_camera.h flexio_ov7670.c flexio_ov7670.h usb_device_config.h FreeRTOSConfig.h
  group sources/ov7670
    ../ov7670/: fsl_sccb_master_driver.c fsl_sccb_master_driver.h ov7670_def.h ov7670_driver.c ov7670_driver.h
  group freertos
    ../../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../rtos/freertos_8.2.3/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
    ../../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
  group utilities
    ../../../../../../devices/MK82F25615/utilities/: fsl_debug_console.c fsl_debug_console.h
  group usb-include
    ../../../../../../middleware/usb_1.0.0/include/: usb.h
  group usb-device-include
    ../../../../../../middleware/usb_1.0.0/device/: usb_device.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
target dev_video_flexio_ov7670_freertos Release (ARM-ADS)
  device: MK82FN256xxx15 Freescale
  pack: Keil.Kinetis_K80_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_video_flexio_ov7670_freertos.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: _DEBUG=0, CPU_MK82FN256VDC15, USB_STACK_FREERTOS_HEAP_SIZE=32768, USB_STACK_FREERTOS, FSL_RTOS_FREE_RTOS, FRDM_K82F, FREEDOM
  c misc: as above
  c include: as above
  asm include: ..;../ov7670
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: MK82FN256xxx15_flash.scf
  link misc: --remove
