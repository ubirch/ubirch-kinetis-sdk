# IAR project bubble.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK82FN256xxx15 Freescale MK82FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK82FN256VDC15; FRDM_K82F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK82F25615/drivers; ..; ../../../../../devices/MK82F25615/utilities; ../../..; ../../../../../devices/MK82F25615
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: bubble.out
  ILINK.IlinkIcfFile: MK82FN256xxx15_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK82FN256VDC15; FRDM_K82F; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MK82F25615/iar/: startup_MK82F25615.s
    ../../../../../devices/MK82F25615/: system_MK82F25615.c system_MK82F25615.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK82F25615/drivers/: fsl_ftm.c fsl_ftm.h fsl_i2c.h fsl_i2c.c fsl_lpuart.h fsl_lpuart.c fsl_lptmr.c fsl_lptmr.h fsl_gpio.h fsl_gpio.c fsl_port.h fsl_smc.h fsl_smc.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c
  group accel
    ../: fsl_fxos.h fsl_fxos.c
  group source
    ../: bubble.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MK82F25615/utilities/: fsl_debug_console.c fsl_debug_console.h
