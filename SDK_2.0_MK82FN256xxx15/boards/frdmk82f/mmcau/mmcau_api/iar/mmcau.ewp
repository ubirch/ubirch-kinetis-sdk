# IAR project mmcau.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK82FN256xxx15 Freescale MK82FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK82FN256VDC15; FRDM_K82F; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK82F25615/drivers; ..; ../../../../../middleware/mmcau_2.0.0; ../../../../../devices/MK82F25615/utilities; ../../..; ../../../../../devices/MK82F25615
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: mmcau.out
  ILINK.IlinkIcfFile: MK82FN256xxx15_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/mmcau_2.0.0/asm-cm4-cm7/lib_mmcau.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK82FN256VDC15; FRDM_K82F; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MK82F25615/iar/: startup_MK82F25615.s
    ../../../../../devices/MK82F25615/: system_MK82F25615.c system_MK82F25615.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK82F25615/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_clock.h fsl_clock.c
  group source
    ../: mmcau_api.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group mmcau/mmcau_include
    ../../../../../middleware/mmcau_2.0.0/: cau_api.h fsl_mmcau.h
  group mmcau/mmcau_source
    ../../../../../middleware/mmcau_2.0.0/: fsl_mmcau.c
  group utilities
    ../../../../../devices/MK82F25615/utilities/: fsl_debug_console.c fsl_debug_console.h
